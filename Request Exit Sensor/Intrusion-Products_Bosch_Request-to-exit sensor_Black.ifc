Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T17:21:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 17:21:03 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{78195C41-CE00-4FE1-8162-A94106085BB1}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 17:21:02 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 17:21:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 17:21:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: Request-to-Exit Sensor, Black, Intrusion-Products_Bosch_Request-to-exit sensor_Black:Request-to-Exit_Sensor_Black:227715
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_75_30_30_71 Request-to-exit buttons (Uniclass 2015); Material: Xtech_Bosch_ABS_Black
Type - Constraints - Default Elevation: 1300 mm
Type - Dimensions - 2DSymbolOffset: 3 mm; Dimension depth (cm): 3.8; Dimension height (cm): 15.9; Dimension width (cm): 3.8
Type - General - Current consumption (mA): 26 mA; Operating temperature (°C) (maximum): 49; Operating temperature (°C) (minimum): -29; Operating voltage (VDC) (maximum): 24; Operating voltage (VDC) (minimum): 12
Type - Identity Data - Description: Request-to-Exit Sensor_Black; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/Installation_Manual_enUS_9007203538027275.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: NA; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS150i_DS151i_Data_sheet_enUS_9007201889618699.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/DS150i-Series-Request-to-exit-Detectors/p/F.01U.364.858/; Type Name: Request-to-Exit_Sensor_Black
Type - Materials and Finishes - Color: Black; Material: High‑impact ABS plastic enclosure
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Request-to-exit sensor_Black
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - TP161 Trim plate: yes
Dimensions - Volume: 0.00021202 m3
Identity Data - CTN: DS151I & TP161; Mark: 19; Material number: F.01U.364.867
Other - 2D_Flipped Position: yes; 2D_Original Position: no; Family: Intrusion-Products_Bosch_Request-to-exit sensor_Black: Request-to-Exit_Sensor_Black; Family and Type: Intrusion-Products_Bosch_Request-to-exit sensor_Black: Request-to-Exit_Sensor_Black; Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_Request-to-exit sensor_Black: Request-to-Exit_Sensor_Black; Type Id: Intrusion-Products_Bosch_Request-to-exit sensor_Black: Request-to-Exit_Sensor_Black
Phasing - Phase Created: New Construction
